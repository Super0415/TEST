# Keil uVision project pro.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F101ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pro +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: .\user;.\app\led;.\app\system;.\app\key;.\app\beep;.\app\nixieTube;.\app\usart;.\app\lcd;.\app\gui
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./app/led/: led.c
    ./app/system/: system.c
    ./app/key/: key.c
    ./app/beep/: beep.c
    ./app/nixieTube/: nixietube.c
    ./app/usart/: usart.c
    ./app/gui/: gui.c
    ./app/lcd/: lcd_driver.c
  group user
    ./: STM32F10x.s
    ./user/: main.c
