# IAR project SoftGenSet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: STM32F10x_StdPeriph_Driver\inc; User; BSP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: SoftGenSet.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    BSP/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c arm_common_tables.c ASMCortex.s CAN1Cortex.c CAN2Cortex.c CCPCortex.c CTLCortex.c DBCortex.c FFTCortex.c FWCortex.c LCDCortex.c OSCortex.c RTCCortex.c SAEJ1939.c SCI1Cortex.c SCI2Cortex.c SCI3Cortex.c SCI4Cortex.c SCI5Cortex.c SFCortex.c SPI1Cortex.c SPI2Cortex.c SPI3Cortex.c XIOCortex.c
  group BSP/inc
    BSP/inc/: arm_common_tables.h arm_const_structs.h arm_math.h CAN1Cortex.h CAN2Cortex.h CCPCortex.h CTLCortex.h DBCortex.h ERRCortex.h FFTCortex.h FWCortex.h LCDCortex.h OSCortex.h RTCCortex.h SAEJ1939.h SCI1Cortex.h SCI2Cortex.h SCI3Cortex.h SCI4Cortex.h SCI5Cortex.h SFCortex.h SPI1Cortex.h SPI2Cortex.h SPI3Cortex.h TYPCortex.h XIOCortex.h
  group STlib/CMSIS
    User/: startup_stm32f10x_hd.s
  group STlib/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STlib/src
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
    User/: stm32f10x_it.c system_stm32f10x.c
