# IAR project GenSet001.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GenSet001.srec
  ILINK.IlinkOutputFile: GenSet001.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_common_tables.h arm_const_structs.h arm_math.h ASMCortex.s CAN1Cortex.c CAN1Cortex.h CAN2Cortex.c CAN2Cortex.h CCPCortex.c CCPCortex.h CTLCortex.c CTLCortex.h DBCortex.c DBCortex.h ERRCortex.h FFTCortex.c FFTCortex.h FWCortex.c FWCortex.h LCDCortex.c LCDCortex.h OSCortex.c OSCortex.h RTCCortex.c RTCCortex.h SAEJ1939.c SAEJ1939.h SCI1Cortex.c SCI1Cortex.h SCI2Cortex.c SCI2Cortex.h SCI3Cortex.c SCI3Cortex.h SCI4Cortex.c SCI4Cortex.h SCI5Cortex.c SCI5Cortex.h SFCortex.c SFCortex.h SPI1Cortex.c SPI1Cortex.h SPI2Cortex.c SPI2Cortex.h SPI3Cortex.c SPI3Cortex.h startup_stm32f105xc.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h TYPCortex.h XIOCortex.c XIOCortex.h
