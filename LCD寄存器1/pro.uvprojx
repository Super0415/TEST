# Keil uVision project pro.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: .\user;.\app\led;.\app\system;.\app\key;.\app\beep;.\app\nixieTube;.\app\usart;.\app\lcd;.\app\gui;.\LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/system/: system.c
  group user
    ./: STM32F10x.s
    ./user/: main.c
  group LCD
    ./LCD/: lcd.c lcd_botton.c
software components: CMSIS:CORE 4.3.0
